# Keil uVision project Keyboard.uvprojx, settings and files
target STM32F746 Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Keyboard
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source
    ./: Keyboard.c stdout_display.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, USB:CORE 6.7.0, USB:Host 6.7.0, USB:Host:HID 6.7.0, Board Support:Drivers:SDRAM 1.0.0, Board Support:Graphic LCD 1.0.0, CMSIS Driver:USB Host:Full-speed 1.6, CMSIS Driver:USB Host:High-speed 1.8, Compiler:I/O:STDOUT 1.1.0, Device:STM32Cube Framework:Classic 1.2.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.1.0, Device:STM32Cube HAL:DMA 1.1.0, Device:STM32Cube HAL:GPIO 1.1.0, Device:STM32Cube HAL:LTDC 1.1.0, Device:STM32Cube HAL:PWR 1.1.0, Device:STM32Cube HAL:RCC 1.1.0, Device:STM32Cube HAL:SDRAM 1.1.0, Device:STM32Cube HAL:SRAM 1.1.0, Device:Startup 1.2.0
